# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\Include; ..\..\User\Lora\LoraDrivers\inc; ..\..\User\Lora\LoraNetWork\inc; ..\..\User\app\inc; ..\..\User\bsp_A; ..\..\User\bsp_A\inc; ..\..\User\bsp_J\inc; ..\..\User\bsp_F\inc; ..\..\User\cJson; ..\..\User\Middleware\inc; ..\..\User\FatFs; ..\..\User\FatFs\option; ..\..\uCOS-II\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\uCOS-II\uCOS-II\Source; ..\..\uCOS-II\uC-LIB; ..\..\uCOS-II\uC-LIB\Ports\ARM-Cortex-M3\IAR; ..\..\uCOS-II\uC-CPU; ..\..\uCOS-II\uC-CPU\ARM-Cortex-M3\IAR; ..\..\User
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.bin
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: stm32-f1.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group BSP安富莱
    ../../User/bsp_A/: bsp.c bsp.h
    ../../User/bsp_A/src/: bsp_cpu_flash.c bsp_fsmc_sram.c bsp_key.c bsp_led.c bsp_tim_pwm.c bsp_timer.c bsp_uart_fifo.c
  group BSP精诚
    ../../User/bsp_J/src/: bsp_IAP.c bsp_N720_J.c bsp_Rs8025t_J.c bsp_temperature_J.c bsp_ZLG_IIC_J.c
  group BSP野火
    ../../User/bsp_F/src/: bsp_spi_flash_fire.c bsp_sram_fire.c
  group cJSON
    ../../User/cJson/: cJSON.c
  group CMSIS
    ../../User/bsp_A/: system_stm32f10x.c
  group EWARMv6
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_hd.s
  group FatFs
    ../../User/FATFS/option/: ccsbcs.c
    ../../User/FATFS/: diskio.c ff.c
  group LORA
    ../../User/Lora/LoraDrivers/Src/: Sx1278_LoRa.c Sx1278_LoRaMisc.c Sx1278_Spi.c
  group Middleware
    ../../User/Middleware/Src/: Math_Lib.c State.c ZLG_Queue.c
  group Stdperiph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group uC/CPU
    ../../uCOS-II/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../uCOS-II/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../uCOS-II/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../uCOS-II/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/OS-II Port
    ../../uCOS-II/uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II Source
    ../../uCOS-II/uCOS-II/Source/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group User/APP
    ../../User/: app.c app_hooks.c cpu_bsp.c
    ../../User/app/src/: GateWayInit.c GateWayReset.c GateWayTaskQueue.c GateWayTemp.c GateWayVariable.c GW3761_2013.c LoraNetTask.c MeterLib.c N720MessageQueues.c N720task.c Tcp4GComm.c
    ../../User/bsp_A/: stm32f10x_it.c
  group User/CONFIG
    ../../User/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_cfg.h
    ../../User/app/inc/: LoraNetTask.h
    ../../User/bsp_A/: stm32f10x_assert.c
  group User/Protocol
    ../../User/Lora/LoraNetWork/Src/: LoRaProtocol.c
